Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Property Type Element Parameter: On], Option [Quantity Type Element Parameter: On], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: D:\Desktop\DG12_OK.ifc
Time: 2017-12-21T14:44:10
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 21.0.0 FRA FULL Windows version (IFC2x3 add-on version: 3005 FRA FULL).
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0, 0; RefLongitude: 54, 25, 0, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey (3)
In: Default Building
Name | Description | Elevation (mm)
RdC | Description of Default Building Storey | 0
R+1 | Description of Default Building Storey | 2810
Toiture |  | 11570

# IfcBuildingElementProxy: Elément Modèle 1 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 1; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_1 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Angle de rotation (deg) | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
caisson VMC | RdC | Matériau de construction IFC (1) | caisson VMC | Sans Trame | RdC | Surface IFC (5) | -5156.62 | Surface IFC (14) | 0.224 | 400 | 0 | 560 | 3560 | 3570 | 3560 | 1.30151 | 400 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_1 - Matériau de construction 1: Tuile de toit 09
cheminée 1 | Toiture | IFC Hachure | cheminée 1 | IFC Hachure | Toiture | Surface IFC | 0 | Enduit - Blanc nature | 1.23032 | 4928.15 | 3.13085 | 1580 | 1000 | 1010 | -10570 | 21.5625 | 778.686 | AC_Pset_Elément_Modèle_1 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 10 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 10; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_10 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
gaines CTA air rejeté | RdC | Matériau de construction IFC (1) | gaines CTA air rejeté | Sans Trame | RdC | Surface IFC (5) | Surface IFC (14) | 2.84277 | 7643.14 | 0 | 1425.84 | 3640.83 | 3650.83 | 3640.83 | 10.2505 | 1993.76 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_10 - Matériau de construction 1: Tuile de toit 09
croupes r+1 | Toiture | IFC Hachure | croupes r+1 | IFC Hachure | Toiture | Surface IFC (4) | Enduit - Blanc nature | 6.51822 | 1572.81 | 0.852735 | 1590.37 | 4610 | 4620 | -6960 | 28.3727 | 4098.56 | AC_Pset_Elément_Modèle_10 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 11 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 11; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_11 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
Object | RdC | Matériau de construction IFC (1) | Object | Sans Trame | RdC | Surface IFC (8) | Surface IFC (14) | 0.363 | 200 | 0.0726 | 550 | 0 | 10 | 0 | 1.21 | 660 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_11 - Matériau de construction 1: Tuile de toit 09
menuiseries toit | Toiture | IFC Hachure | menuiseries toit | IFC Hachure | Toiture | Surface IFC (5) | Enduit - Blanc nature | 0.882488 | 1280 | 0.0227423 | 235.097 | 4222.67 | 4232.67 | -7347.33 | 4.19328 | 3753.71 | AC_Pset_Elément_Modèle_11 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 12, r+1 menuiseries extérieures
In: R+1
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: r+1 menuiseries extérieures; Lien et ID d'élément: r+1 menuiseries extérieures; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 12; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: R+1; Type: Objet; ID de Parent: r+1 menuiseries extérieures; Surface (Toute): Surface IFC (5); Surface IFC (2); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_12 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Surface 2: Surface IFC (2); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 198.004 m2; Hauteur: 2809.15 mm; Volume net: 0.491546 m3; Largeur: 6492.88 mm; Altitude à Zéro du Projet: 3555 mm; Altitude de Référence Niveau 1: 3555 mm; Altitude de Référence Niveau 2: 3555 mm; Altitude à niveau de la mer: 3565 mm; Altitude à étage: 745 mm; Décalage étage d'implantation: 745 mm; Superficie de surface: 130.202 m2; Hauteur (Taille en Z): 2809.15 mm; Longueur (A): 30495.5 mm; Largeur (B): 6492.88 mm

# IfcBuildingElementProxy: Elément Modèle 13, menuiseries intérieures r+1
In: R+1
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: menuiseries intérieures r+1; Lien et ID d'élément: menuiseries intérieures r+1; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 13; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: R+1; Type: Objet; ID de Parent: menuiseries intérieures r+1; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_13 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 136.028 m2; Hauteur: 2100 mm; Volume net: -0.4539 m3; Largeur: 4667.51 mm; Altitude à Zéro du Projet: 3560 mm; Altitude de Référence Niveau 1: 3560 mm; Altitude de Référence Niveau 2: 3560 mm; Altitude à niveau de la mer: 3570 mm; Altitude à étage: 750 mm; Décalage étage d'implantation: 750 mm; Superficie de surface: 74.341 m2; Hauteur (Taille en Z): 2100 mm; Longueur (A): 29143.6 mm; Largeur (B): 4667.51 mm

# IfcBuildingElementProxy: Elément Modèle 14, murs r+1
In: R+1
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: murs r+1; Lien et ID d'élément: murs r+1; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 14; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: R+1; Type: Objet; ID de Parent: murs r+1; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_14 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 242.246 m2; Hauteur: 3476.26 mm; Volume net: 0.955995 m3; Largeur: 6292.88 mm; Altitude à Zéro du Projet: 2810 mm; Altitude de Référence Niveau 1: 2810 mm; Altitude de Référence Niveau 2: 2810 mm; Altitude à niveau de la mer: 2820 mm; Altitude à étage: 0 mm; Décalage étage d'implantation: 0 mm; Superficie de surface: 867.898 m2; Hauteur (Taille en Z): 3476.26 mm; Longueur (A): 38495.2 mm; Largeur (B): 6292.88 mm

# IfcBuildingElementProxy: Elément Modèle 15, plancher r+1
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: plancher r+1; Lien et ID d'élément: plancher r+1; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 15; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; ID de Parent: plancher r+1; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_15 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 216.555 m2; Hauteur: 1160.02 mm; Volume net: 0 m3; Largeur: 5687.4 mm; Altitude à Zéro du Projet: 2399.98 mm; Altitude de Référence Niveau 1: 2399.98 mm; Altitude de Référence Niveau 2: 2399.98 mm; Altitude à niveau de la mer: 2409.98 mm; Altitude à étage: 2399.98 mm; Décalage étage d'implantation: 2399.98 mm; Superficie de surface: 585.738 m2; Hauteur (Taille en Z): 1160.02 mm; Longueur (A): 38076.4 mm; Largeur (B): 5687.4 mm

# IfcBuildingElementProxy: Elément Modèle 16, toit rdc
In: Toiture
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: toit rdc; Lien et ID d'élément: toit rdc; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 16; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: Toiture; Type: Objet; ID de Parent: toit rdc; Surface (Toute): Surface IFC (4); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_16 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (4); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 17.6006 m2; Hauteur: 1514.44 mm; Volume net: 0 m3; Largeur: 3960.23 mm; Altitude à Zéro du Projet: 1.95804 mm; Altitude de Référence Niveau 1: 1.95804 mm; Altitude de Référence Niveau 2: 1.95804 mm; Altitude à niveau de la mer: 11.958 mm; Altitude à étage: -11568 mm; Décalage étage d'implantation: -11568 mm; Superficie de surface: 42.996 m2; Hauteur (Taille en Z): 1514.44 mm; Longueur (A): 4444.33 mm; Largeur (B): 3960.23 mm

# IfcBuildingElementProxy: Elément Modèle 17, menuiseries extérieures
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: menuiseries extérieures; Lien et ID d'élément: menuiseries extérieures; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 17; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; ID de Parent: menuiseries extérieures; Surface (Toute): Surface IFC (2); Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_17 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (2); Surface 2: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 331.183 m2; Hauteur: 3280.32 mm; Volume net: 0.233557 m3; Largeur: 9381.37 mm; Altitude à Zéro du Projet: 1.74703e-10 mm; Altitude de Référence Niveau 1: 1.74703e-10 mm; Altitude de Référence Niveau 2: 1.74703e-10 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: 1.74703e-10 mm; Décalage étage d'implantation: 1.74703e-10 mm; Superficie de surface: 166.303 m2; Hauteur (Taille en Z): 3280.32 mm; Longueur (A): 35302.2 mm; Largeur (B): 9381.37 mm

# IfcBuildingElementProxy: Elément Modèle 18, menuiseries intérieures rdc
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: menuiseries intérieures rdc; Lien et ID d'élément: menuiseries intérieures rdc; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 18; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; ID de Parent: menuiseries intérieures rdc; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_18 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 189.816 m2; Hauteur: 2100 mm; Volume net: 0.77214 m3; Largeur: 5221.1 mm; Altitude à Zéro du Projet: 1.87697e-10 mm; Altitude de Référence Niveau 1: 1.87697e-10 mm; Altitude de Référence Niveau 2: 1.87697e-10 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: 1.87697e-10 mm; Décalage étage d'implantation: 1.87697e-10 mm; Superficie de surface: 83.5308 m2; Hauteur (Taille en Z): 2100 mm; Longueur (A): 36355.6 mm; Largeur (B): 5221.1 mm

# IfcBuildingElementProxy: Elément Modèle 19, murs rdc
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: murs rdc; Lien et ID d'élément: murs rdc; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 19; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; ID de Parent: murs rdc; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_19 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 405.445 m2; Hauteur: 3575 mm; Volume net: 0.561719 m3; Largeur: 10537 mm; Altitude à Zéro du Projet: 1.84809e-10 mm; Altitude de Référence Niveau 1: 1.84809e-10 mm; Altitude de Référence Niveau 2: 1.84809e-10 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: 1.84809e-10 mm; Décalage étage d'implantation: 1.84809e-10 mm; Superficie de surface: 1318.67 m2; Hauteur (Taille en Z): 3575 mm; Longueur (A): 38478.2 mm; Largeur (B): 10537 mm

# IfcBuildingElementProxy: Elément Modèle 2 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 2; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_2 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Angle de rotation (deg) | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
gaines VMC air rejeté en toiture | RdC | Matériau de construction IFC (1) | gaines VMC air rejeté en toiture | Sans Trame | RdC | Surface IFC (5) | -5156.62 | Surface IFC (14) | 1.08304 | 7251.55 | 0 | 1337.66 | 3635 | 3645 | 3635 | 7.11591 | 809.657 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_2 - Matériau de construction 1: Tuile de toit 09
cheminée 2 | Toiture | IFC Hachure | cheminée 2 | IFC Hachure | Toiture | Surface IFC | 0 | Enduit - Blanc nature | 1.23032 | 4928.15 | 3.13085 | 1580 | 1000 | 1010 | -10570 | 21.5625 | 778.686 | AC_Pset_Elément_Modèle_2 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 20, toit existant
In: Toiture
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: toit existant; Lien et ID d'élément: toit existant; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 20; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: Toiture; Type: Objet; ID de Parent: toit existant; Surface (Toute): Surface IFC (1); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_20 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (1); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 173.015 m2; Hauteur: 5215.69 mm; Volume net: 0 m3; Largeur: 7174.51 mm; Altitude à Zéro du Projet: 16 mm; Altitude de Référence Niveau 1: 16 mm; Altitude de Référence Niveau 2: 16 mm; Altitude à niveau de la mer: 26 mm; Altitude à étage: -11554 mm; Décalage étage d'implantation: -11554 mm; Superficie de surface: 478.298 m2; Hauteur (Taille en Z): 5215.69 mm; Longueur (A): 24115.3 mm; Largeur (B): 7174.51 mm

# IfcBuildingElementProxy: Elément Modèle 21, menuiseries extérieures r+1
In: R+1
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: menuiseries extérieures r+1; Lien et ID d'élément: menuiseries extérieures r+1; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 21; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: R+1; Type: Objet; ID de Parent: menuiseries extérieures r+1; Surface (Toute): Surface IFC (6); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_21 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (6); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 59.2249 m2; Hauteur: 2730.01 mm; Volume net: 0.055623 m3; Largeur: 6784.06 mm; Altitude à Zéro du Projet: -8.88178e-13 mm; Altitude de Référence Niveau 1: -8.88178e-13 mm; Altitude de Référence Niveau 2: -8.88178e-13 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: -2810 mm; Décalage étage d'implantation: -2810 mm; Superficie de surface: 38.4913 m2; Hauteur (Taille en Z): 2730.01 mm; Longueur (A): 8730 mm; Largeur (B): 6784.06 mm

# IfcBuildingElementProxy: Elément Modèle 22, toit extension
In: Toiture
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: toit extension; Lien et ID d'élément: toit extension; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 22; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: Toiture; Type: Objet; ID de Parent: toit extension; Surface (Toute): Surface IFC (4); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_22 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (4); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 73.7568 m2; Hauteur: 3126.27 mm; Volume net: 110.573 m3; Largeur: 7079.68 mm; Altitude à Zéro du Projet: 4.73525 mm; Altitude de Référence Niveau 1: 4.73525 mm; Altitude de Référence Niveau 2: 4.73525 mm; Altitude à niveau de la mer: 14.7352 mm; Altitude à étage: -11565.3 mm; Décalage étage d'implantation: -11565.3 mm; Superficie de surface: 190.442 m2; Hauteur (Taille en Z): 3126.27 mm; Longueur (A): 10418.1 mm; Largeur (B): 7079.68 mm

# IfcBuildingElementProxy: Elément Modèle 23, rdc menuiseries extérieures
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - ID Elément: rdc menuiseries extérieures; Lien et ID d'élément: rdc menuiseries extérieures; Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 23; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; ID de Parent: rdc menuiseries extérieures; Surface (Toute): Surface IFC (6); Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_23 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (6); Surface 2: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 50.5362 m2; Hauteur: 3460 mm; Volume net: 0 m3; Largeur: 6270 mm; Altitude à Zéro du Projet: 1.89141e-10 mm; Altitude de Référence Niveau 1: 1.89141e-10 mm; Altitude de Référence Niveau 2: 1.89141e-10 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: 1.89141e-10 mm; Décalage étage d'implantation: 1.89141e-10 mm; Superficie de surface: 19.0173 m2; Hauteur (Taille en Z): 3460 mm; Longueur (A): 8060 mm; Largeur (B): 6270 mm

# IfcBuildingElementProxy: Elément Modèle 24
In: R+1
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 24; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: R+1; Type: Objet; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_24 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 63.2836 m2; Hauteur: 3170 mm; Volume net: 0 m3; Largeur: 6444.36 mm; Altitude à Zéro du Projet: 2427.27 mm; Altitude de Référence Niveau 1: 2427.27 mm; Altitude de Référence Niveau 2: 2427.27 mm; Altitude à niveau de la mer: 2437.27 mm; Altitude à étage: -382.727 mm; Décalage étage d'implantation: -382.727 mm; Superficie de surface: 258.099 m2; Hauteur (Taille en Z): 3170 mm; Longueur (A): 9820 mm; Largeur (B): 6444.36 mm

# IfcBuildingElementProxy: Elément Modèle 25
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 25; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; Surface (Toute): Surface IFC (5); Surface IFC (7); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_25 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Surface 2: Surface IFC (7); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 87.4135 m2; Hauteur: 5871.33 mm; Volume net: 0.19482 m3; Largeur: 8479.02 mm; Altitude à Zéro du Projet: 1.89141e-10 mm; Altitude de Référence Niveau 1: 1.89141e-10 mm; Altitude de Référence Niveau 2: 1.89141e-10 mm; Altitude à niveau de la mer: 10 mm; Altitude à étage: 1.89141e-10 mm; Décalage étage d'implantation: 1.89141e-10 mm; Superficie de surface: 402.609 m2; Hauteur (Taille en Z): 5871.33 mm; Longueur (A): 10309.4 mm; Largeur (B): 8479.02 mm

# IfcBuildingElementProxy: Elément Modèle 26
In: RdC
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD); Material: IFC Hachure
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 26; Matériau de construction / Composite / Profil / Hachure: IFC Hachure; Verrouillé: no; Etage d'implantation: RdC; Type: Objet; Surface (Toute): Surface IFC (5); Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Surface: Enduit - Blanc nature; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_26 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Surface par défaut: Enduit - Blanc nature; Surface 1: Surface IFC (5); Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Superficie: 59.2144 m2; Hauteur: 200 mm; Volume net: 8.12368 m3; Largeur: 6220 mm; Altitude à Zéro du Projet: 3360 mm; Altitude de Référence Niveau 1: 3360 mm; Altitude de Référence Niveau 2: 3360 mm; Altitude à niveau de la mer: 3370 mm; Altitude à étage: 3360 mm; Décalage étage d'implantation: 3360 mm; Superficie de surface: 90.5912 m2; Hauteur (Taille en Z): 200 mm; Longueur (A): 9520 mm; Largeur (B): 6220 mm

# IfcBuildingElementProxy: Elément Modèle 3 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 3; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_3 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
gaines VMC r+1 | RdC | Matériau de construction IFC (1) (5) | gaines VMC r+1 | Sans Trame | RdC | Surface IFC (5) | Surface IFC (14) | 0.1775 | 2735 | 0 | 250 | 3460 | 3470 | 3460 | 1.96627 | 710 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_3 - Matériau de construction 1: Tuile de toit 09
cheminée 3 | Toiture | IFC Hachure | cheminée 3 | IFC Hachure | Toiture | Surface IFC | Enduit - Blanc nature | 1.23032 | 4928.15 | 3.13085 | 1580 | 2.02505e-10 | 10 | -11570 | 21.5625 | 778.686 | AC_Pset_Elément_Modèle_3 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 4 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 4; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_4 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Volume net: 0 m3
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
gaines VMC RDC | RdC | Matériau de construction IFC (1) (2) | gaines VMC RDC | Sans Trame | RdC | Surface IFC (5) | Surface IFC (14) | 0.16125 | 690 | 250 | 2770 | 2780 | 2770 | 0.688826 | 645 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_4 - Matériau de construction 1: Tuile de toit 09
croupes | Toiture | IFC Hachure | croupes | IFC Hachure | Toiture | Surface IFC (1) | Enduit - Blanc nature | 127.729 | 2425.16 | 6715.29 | 7090 | 7100 | -4480 | 68.1379 | 19020.6 | AC_Pset_Elément_Modèle_4 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 5 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 5; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_5 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
sortie VMC toiture | RdC | Matériau de construction IFC (1) (2) | sortie VMC toiture | Sans Trame | RdC | Surface IFC (8) | Surface IFC (14) | 1.11023 | 846.569 | 0.0726 | 1008.67 | 10396.1 | 10406.1 | 10396.1 | 2.43143 | 1100.68 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_5 - Matériau de construction 1: Tuile de toit 09
fenêtre toiture | Toiture | IFC Hachure | fenêtre toiture | IFC Hachure | Toiture | Surface IFC (2) | Enduit - Blanc nature | 106.149 | 1640.17 | 0 | 5700.13 | 7304.57 | 7314.57 | -4265.43 | 37.8392 | 18622.2 | AC_Pset_Elément_Modèle_5 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 6 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 6; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_6 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) | Surface | Surface 1 | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
CTA | RdC | Matériau de construction IFC (1) (2651) | CTA | Sans Trame | RdC | Surface IFC (5); Surface IFC (9); Surface IFC (6); Surface IFC (10); Surface IFC (11); Surface IFC (12); Surface IFC (13) | Surface IFC (14) | Surface IFC (5) | 0.836226 | 1021.43 | 0.00188339 | 1756.07 | 3560 | 3570 | 3560 | 12.6854 | 476.19 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_6 - Matériau de construction 1: Tuile de toit 09; Surface 2: Surface IFC (9); Surface 3: Surface IFC (6); Surface 4: Surface IFC (10); Surface 5: Surface IFC (11); Surface 6: Surface IFC (12); Surface 7: Surface IFC (13)
cheminée 4 | Toiture | IFC Hachure | cheminée 4 | IFC Hachure | Toiture | Surface IFC (3) | Enduit - Blanc nature | Surface IFC (3) | 1.23032 | 3494.93 | 2.2498 | 1580 | -0.0894607 | 9.91054 | -11570.1 | 15.8308 | 778.686 | AC_Pset_Elément_Modèle_6 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 7 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 7; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_7 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
reprise CTA | RdC | Matériau de construction IFC (1) (23) | reprise CTA | Sans Trame | RdC | Surface IFC (5) | Surface IFC (14) | 0.934467 | 1348.56 | 0 | 1509.52 | 3380.48 | 3390.48 | 3380.48 | 3.34042 | 619.048 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_7 - Matériau de construction 1: Tuile de toit 09
cheminée 5 | Toiture | IFC Hachure | cheminée 5 | IFC Hachure | Toiture | Surface IFC (3) | Enduit - Blanc nature | 0.23096 | 2726.21 | 0.370597 | 507.29 | 1.88294e-10 | 10 | -11570 | 4.3981 | 455.282 | AC_Pset_Elément_Modèle_7 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 8 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 8; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_8 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) = Surface 1 | Surface | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
souflage CTA | RdC | Matériau de construction IFC (1) (20) | souflage CTA | Sans Trame | RdC | Surface IFC (5) | Surface IFC (14) | 0.931519 | 803.326 | 0 | 1504.76 | 3154.29 | 3164.29 | 3154.29 | 2.62718 | 619.048 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_8 - Matériau de construction 1: Tuile de toit 09
toit 1 r+1 | Toiture | IFC Hachure | toit 1 r+1 | IFC Hachure | Toiture | Surface IFC (4) | Enduit - Blanc nature | 66.6102 | 3130.6 | 103.555 | 6647.95 | -0.264752 | 9.73525 | -11570.3 | 176.501 | 10019.6 | AC_Pset_Elément_Modèle_8 - Surface par défaut: Enduit - Blanc nature

# IfcBuildingElementProxy: Elément Modèle 9 (2)
Description: Description of Object; Classification: Elément de construction non défini (Classification ARCHICAD)
ArchiCADProperties - Calque: IFC Calque.Importation IFC; Nom Elément de Bibliothèque: Elément Modèle 9; Verrouillé: no; Type: Objet; Fonction structurelle: Non défini; Position: Non défini; Afficher sur filtre de rénovation: Tous les filtres appropriés; Etat de rénovation: Existant; Angle de rotation: 0 deg; Classification ARCHICAD - 20: Elément de construction non défini
AC_Pset_Elément_Modèle_9 - Type Hachure: Sans Trame; Stylo Hachure: Fond - Couleur 1; Stylo fond hachure: Fond - Couleur 1; Stylo de contour: Eléments 2D - Général; Afficher arêtes de contour seulement en 3D: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | ID Elément = Lien et ID d'élément = ID de Parent | Matériau de construction / Composite / Profil / Hachure | Etage d'implantation | Surface (Toute) | Surface | Surface 1 | Superficie (m2) | Hauteur (mm) = Hauteur (Taille en Z) (mm) | Volume net (m3) | Largeur (mm) = Largeur (B) (mm) | Altitude à Zéro du Projet (mm) = Altitude de Référence Niveau 1 (mm) = Altitude de Référence Niveau 2 (mm) | Altitude à niveau de la mer (mm) | Altitude à étage (mm) = Décalage étage d'implantation (mm) | Superficie de surface (m2) | Longueur (A) (mm)
gaines CTA air neuf | RdC | Matériau de construction IFC (1) (2630) | gaines CTA air neuf | Sans Trame | RdC | Surface IFC (6); Surface IFC (10); Surface IFC (11); Surface IFC (12); Surface IFC (5) | Surface IFC (14) | Surface IFC (6) | 6.04029 | 454.93 | -0.000797257 | 3838.34 | 4116.1 | 4126.1 | 4116.1 | 5.73683 | 1573.67 | ArchiCADProperties - Matériaux de construction (Tous): Matériau de construction IFC (1); AC_Pset_Elément_Modèle_9 - Matériau de construction 1: Tuile de toit 09; Surface 2: Surface IFC (10); Surface 3: Surface IFC (11); Surface 4: Surface IFC (12); Surface 5: Surface IFC (5)
toit 2 r+1 | Toiture | IFC Hachure | toit 2 r+1 | IFC Hachure | Toiture | Surface IFC (4) | Enduit - Blanc nature | Surface IFC (4) | 39.3447 | 3053.15 | 0 | 6450.79 | -0.00000120092 | 10 | -11570 | 71.9621 | 6099.21 | AC_Pset_Elément_Modèle_9 - Surface par défaut: Enduit - Blanc nature
